## rk3328/gpio_test/Config.in
```kconfig
config BR2_PACKAGE_GPIO_TEST
	bool "gpio_test"
	help
		GPIO test package.

		http://example.com
```
